# Keil uVision project sample1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: sample1
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s cfg_PINSEL0.c cfg_PINSEL0_PINSEL1.c cfg_reg.c cfg_same_pin.c cfg_same_pin_clear_bit.c cfg_same_pin_clear_or_combine.c pin_connect_block.c

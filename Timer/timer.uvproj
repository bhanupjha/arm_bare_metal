# Keil uVision project timer.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: timer +hex
  c flags: Optim=1
  c include: ..\Common;..\Timer
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s timer0_delay.c timer0_test.c
    ../LCD/: LCD.c LCD_test.c

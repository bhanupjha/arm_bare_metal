# Keil uVision project LPC2129_GPIO.uvproj, settings and files
target LPC2129_GPIO (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC2129_GPIO
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group GPIO
    ./: Startup.s 01_gpio_iodir.c 02_gpio_ioset.c 03_gpio_ioclr.c 04_gpio_iopin.c 05_gpio_toggle_pin.c 06_gpio_toggle_pin_iopin.c 07_gpio_set_clr_switchcase.c gpio_pin_status.c gpio_pin_status_set_clr_ternary.c gpio_pin_status_ternary.c gpio_pin_status_wo_definepin.c gpio_status_iopin_variable.c gpio_status_switchcase.c gpio_toggle_pin_iopin_exor.c 02_gpio_iodir_consecutive_pins.c 03_gpio_iodir_nconsecutive_pins.c gpio_pin_set_0_to_255.c run_time_value_second_highest.c gpio_pin_set_0_to_255_iopin.c
    ../Common/: delay.c

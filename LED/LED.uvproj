# Keil uVision project LED.uvproj, settings and files
target LPC21XX (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SW +hex
  c flags: Optim=1
  c include: ..\Common
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group SW
    ./: Startup.s Buzzer.c
    ../Common/: delay.c
    ../switch/: gpio_pin_status_AL_SW_AL_LED.c

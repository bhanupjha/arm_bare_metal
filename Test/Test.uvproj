# Keil uVision project Test.uvproj, settings and files
target Test (ARM-ADS)
  device: LPC2129 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Test +hex
  c flags: Optim=1
  c include: ..\Common
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Test
    ./: Startup.s AL_LED_SH_binary.c
    ../Common/: delay.c
